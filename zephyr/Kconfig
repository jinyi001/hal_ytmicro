## zephyr/Kconfig
```kconfig
config HAS_YTMICRO_HAL
    bool
    depends on SOC_FAMILY_YTMICRO_YTM32
    default y
```
